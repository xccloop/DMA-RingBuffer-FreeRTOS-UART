<?xml version="1.0" encoding="UTF-8" standalone="no" ?>
<ProjectOpt xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_optx.xsd">
  <SchemaVersion>1.0</SchemaVersion>
  <Header>### uVision Project, (C) Keil Software</Header>
  <Extensions>
    <cExt>
      <Cversion>0</Cversion>
      <MiscControls>--c99</MiscControls>
      <Define>USE_HAL_DRIVER, STM32F103xE</Define>
      <IncludePath>.;.\Core;.\FreeRTOS\include;.\FreeRTOS\portable\RVDS\ARM_CM3;.\HAL\inc;.\System;.\Framework;.\User;.\RTE\_STM32F103ZE</IncludePath>
      <uac>1</uac><Optim>1</Optim><wLevel>2</wLevel>
    </cExt>
    <aExt>
      <Define>STM32F103xE</Define>
      <IncludePath>.\Core;.\System</IncludePath>
    </aExt>
    <DebugOpt><uSim>0</uSim><uTrg>1</uTrg><sDll>0</sDll><tDll>0</tDll></DebugOpt>
  </Extensions>
</ProjectOpt>
