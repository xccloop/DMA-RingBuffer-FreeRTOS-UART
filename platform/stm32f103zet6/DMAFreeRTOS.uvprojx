# Keil uVision project DMAFreeRTOS.uvprojx, settings and files
target DMAFreeRTOS (ARM-ADS)
  group Framework/RingBuffer
    ../../ringbuffer/: ringbuffer.c
  group Framework/Port
    ../../port/stm32f1xx/: uart_port.c
  group Framework/Driver
    ../../driver/: uart_dma.c
  group Framework/API
    ../../api/: uart_api.c
  group Application
    ./: main.c stm32f1xx_it.c
  group Startup
    ./: startup_stm32f103xe.s
  group HAL/STM32F1xx
    __CUBE__/Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
    __CUBE__/Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_uart.c stm32f1xx_hal_rcc.c stm32f1xx_hal_cortex.c stm32f1xx_hal_flash.c stm32f1xx_hal_pwr.c
  group FreeRTOS/Core
    __FREERTOS__/Source/: tasks.c queue.c list.c timers.c
  group FreeRTOS/Portable
    __FREERTOS__/Source/portable/RVDS/ARM_CM3/: port.c
    __FREERTOS__/Source/portable/MemMang/: heap_4.c
