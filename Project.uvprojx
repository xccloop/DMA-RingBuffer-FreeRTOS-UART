# Keil uVision project Project.uvprojx, settings and files
target DMAFreeRTOS (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3")
  output: DMAFreeRTOS
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER, STM32F103xE
  c misc: --c99
  c include: .;.\Core;.\FreeRTOS\include;.\FreeRTOS\portable\RVDS\ARM_CM3;.\HAL\inc;.\System;.\Framework;.\User;.\RTE\_STM32F103ZE
  asm define: STM32F103xE
  asm include: .\Core;.\System
  library: MicroLIB
  memory RVCT1: ROM 0x08000000 size 0x80000
  scatter file: .\STM32F103ZE.sct
  group User
    ./User/: main.c stm32f1xx_it.c
  group Framework
    ./Framework/: ringbuffer.c uart_port.c uart_dma.c uart_api.c
  group FreeRTOS
    ./FreeRTOS/: tasks.c queue.c list.c timers.c
    ./FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ./FreeRTOS/portable/MemMang/: heap_4.c
  group HAL
    ./HAL/src/: stm32f1xx_hal.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_uart.c stm32f1xx_hal_rcc.c stm32f1xx_hal_cortex.c stm32f1xx_hal_flash.c stm32f1xx_hal_pwr.c
  group System
    ./System/: system_stm32f1xx.c
    ./Core/: core_cm3.c startup_stm32f103xe.s
  group Config
    ./FreeRTOS/include/: FreeRTOSConfig.h
    ./User/: stm32f1xx_hal_conf.h
    ./RTE/_STM32F103ZE/: RTE_Components.h
