<?xml version="1.0" encoding="UTF-8" standalone="no" ?>
<ProjectOpt xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_optx.xsd">
  <SchemaVersion>1.0</SchemaVersion>
  <Header>### uVision Project, (C) Keil Software</Header>
  <Extensions>
    <cExt>
      <Cversion>0</Cversion>
      <MiscControls>-Wall -Wextra -fno-common</MiscControls>
      <Define>USE_HAL_DRIVER, STM32F103xE</Define>
      <IncludePath>..\..;..\..\config;..\..\ringbuffer;..\..\driver;..\..\api;..\..\port;.;__FREERTOS__\Source\include;__FREERTOS__\Source\portable\RVDS\ARM_CM3;__CUBE__\Drivers\STM32F1xx_HAL_Driver\Inc;__CUBE__\Drivers\CMSIS\Device\ST\STM32F1xx\Include;__CUBE__\Drivers\CMSIS\Include</IncludePath>
      <uac>1</uac>
      <Optim>3</Optim>
      <wLevel>0</wLevel>
      <VariousControls>
        <Language>1</Language>
        <MISRA>0</MISRA>
      </VariousControls>
    </cExt>
    <aExt>
      <AssemblerAdsDefine>STM32F103xE</AssemblerAdsDefine>
      <AssemblerAdsInclude>__CUBE__\Drivers\CMSIS\Include;__CUBE__\Drivers\CMSIS\Device\ST\STM32F1xx\Include</AssemblerAdsInclude>
    </aExt>
    <DebugOpt>
      <uSim>0</uSim>
      <uTrg>1</uTrg>
      <sDll>0</sDll>
      <tDll>0</tDll>
    </DebugOpt>
    <TargetDriverDllRegistry>
      <SetRegEntry>
        <Number>0</Number>
        <Key>STLink\ST-LINKIII-KEIL-SWO</Key>
        <Name>-U -O340 -SF10000 -C0 -A0 -I0 -HNlocalhost -HP7184 -P2 -N00("ARM CoreSight SW-DP") -D00(2BA01477) -L00(0) -TO18 -TC2000000 -TT10000000 -TP21 -TDX0 -TDD0 -TDS10007F -TDT0 -TDC1F -TIE80000000 -TIP8 -TB1 -TFE0 -FO15 -FD20000000 -FC1000 -FN1 -FF0STM32F1xx_512 -FS080000000 -FL0800000 -FP0($$Device:STM32F103ZE$Flash\STM32F1xx_512.FLM)</Name>
      </SetRegEntry>
    </TargetDriverDllRegistry>
  </Extensions>
</ProjectOpt>
